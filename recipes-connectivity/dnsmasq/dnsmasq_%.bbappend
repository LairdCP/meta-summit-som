SYSTEMD_AUTO_ENABLE = "disable"

PACKAGECONFIG += "dbus"
