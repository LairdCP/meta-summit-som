PACKAGECONFIG:append = " modemmanager"