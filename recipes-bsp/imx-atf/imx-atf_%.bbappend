FILESEXTRAPATHS_prepend := "${THISDIR}/files:"


SRC_URI += " \
	file://0001-enable-m7-rdc-access.patch \
	"
