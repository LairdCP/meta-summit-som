do_compile[depends] += "virtual/kernel:do_deploy"
