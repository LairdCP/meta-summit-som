BT_SERIAL_PORT:imx8mp-summitsom = "/dev/ttymxc2"
