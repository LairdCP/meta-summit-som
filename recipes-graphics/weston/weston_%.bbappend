PACKAGECONFIG_PIPEWIRE:mx8-nxp-bsp:summitsom ?= ""
PACKAGECONFIG_PIPEWIRE:mx9-nxp-bsp:summitsom ?= ""
