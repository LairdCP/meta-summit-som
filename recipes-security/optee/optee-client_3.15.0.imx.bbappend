EXTRA_OEMAKE_append_summitsom = " CFG_TEE_FS_PARENT_PATH=/perm/tee"
