FILES_${PN} += "${base_libdir}/optee_armtz"