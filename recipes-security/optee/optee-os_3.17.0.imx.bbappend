FILES:${PN} += "${base_libdir}/optee_armtz"