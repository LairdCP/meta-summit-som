EXTRA_OEMAKE:append:summitsom = " CFG_TEE_FS_PARENT_PATH=/perm/tee"
