FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-SPIRV-SpvBuilder-h-add-missing-<cstdint>-include.patch"
