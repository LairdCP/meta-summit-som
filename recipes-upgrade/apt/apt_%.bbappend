FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-strutl-Add-missing-include-cstdint-gcc-15.patch"
