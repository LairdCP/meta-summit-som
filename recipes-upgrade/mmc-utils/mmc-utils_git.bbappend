SRCREV = "4303889c8bd9a2357587eb6ebacecb70098a264d"

SRC_URI = "git://git.kernel.org/pub/scm/utils/mmc/mmc-utils.git;branch=${SRCBRANCH}"
