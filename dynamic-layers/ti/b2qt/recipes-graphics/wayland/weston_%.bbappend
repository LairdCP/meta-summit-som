# To remove 'dmabuf-feedback' due to gbm 21.1.1 dependency
SIMPLECLIENTS = "damage,im,egl,shm,touch,dmabuf-v4l,dmabuf-egl"
