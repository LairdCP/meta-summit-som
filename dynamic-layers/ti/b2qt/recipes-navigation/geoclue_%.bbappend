PACKAGECONFIG:remove:summit-b2qt = "3g modem-gps cdma"
