BB_GIT_DEFAULT_DESTSUFFIX = "git"
