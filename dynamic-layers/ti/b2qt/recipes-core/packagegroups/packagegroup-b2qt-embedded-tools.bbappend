RDEPENDS:${PN}:remove = " \
    nfs-utils \
    "
