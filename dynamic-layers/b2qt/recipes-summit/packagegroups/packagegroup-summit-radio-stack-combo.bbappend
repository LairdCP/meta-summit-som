RDEPENDS:${PN}:remove:summit-b2qt = "\
    summit-networkmanager \
    summit-networkmanager-nmcli \
    "
