EXTRA_OEMAKE:summitsom += "KEYBLOB_LOCATION=/perm/caam/"
