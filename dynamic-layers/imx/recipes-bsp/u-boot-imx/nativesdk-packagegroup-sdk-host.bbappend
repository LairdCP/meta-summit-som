RDEPENDS:${PN}:remove = "nativesdk-efitools"
