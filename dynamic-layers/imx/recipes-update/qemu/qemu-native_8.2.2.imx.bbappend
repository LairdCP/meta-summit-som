FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-sched_attr-Do-not-define-for-glibc-2.41.patch"
