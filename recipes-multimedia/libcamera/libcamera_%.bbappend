PACKAGECONFIG:summitsom ?= "gst pycamera"
