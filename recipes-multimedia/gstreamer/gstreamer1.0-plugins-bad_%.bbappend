PACKAGECONFIG:append:summitsom = " kms"
