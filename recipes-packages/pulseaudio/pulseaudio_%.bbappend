PACKAGECONFIG_remove = "ofono"