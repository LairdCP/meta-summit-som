
RDEPENDS:${PN} += "libgcc"
