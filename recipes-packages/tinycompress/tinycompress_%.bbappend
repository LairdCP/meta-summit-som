SRC_URI:remove = "git://git.alsa-project.org/tinycompress.git;protocol=git;branch=master"
SRC_URI =+ "git://git.alsa-project.org/http/tinycompress.git;protocol=https;branch=master"
