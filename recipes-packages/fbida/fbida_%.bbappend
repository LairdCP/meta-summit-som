PACKAGECONFIG:summitsom ?= "png gif"
