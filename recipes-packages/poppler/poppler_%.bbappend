PACKAGECONFIG:summitsom ?= "jpeg openjpeg png tiff"
