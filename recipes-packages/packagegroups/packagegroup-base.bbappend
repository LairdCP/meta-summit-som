RDEPENDS_packagegroup-base-3g_remove = "ofono"