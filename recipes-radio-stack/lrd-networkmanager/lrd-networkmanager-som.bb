require lrd-networkmanager.inc radio-stack-som-version.inc