SUMMARY = "Bluetooth Summit 60 Auto World-Wide Mode for SOM"

require adaptive-bt.inc radio-stack-som-version.inc
