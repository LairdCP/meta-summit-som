require summit-networkmanager.inc radio-stack-som-version.inc