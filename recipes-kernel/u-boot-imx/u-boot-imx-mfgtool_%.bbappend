FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
	file://git \
	file://bsp-integ.patch \
	"
