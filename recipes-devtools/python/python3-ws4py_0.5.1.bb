SUMMARY = "WebSocket client and server library"
HOMEPAGE = "https://github.com/Lawouach/WebSocket-for-Python"
AUTHOR = "Sylvain Hellegouarch <sh@defuze.org>"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3fa2e948e5257fbd577980a9a8a9f746"

SRC_URI[md5sum] = "68e0cfae9659dd059ff7e7a8218af548"
SRC_URI[sha256sum] = "29d073d7f2e006373e6a848b1d00951a1107eb81f3742952be905429dc5a5483"

inherit pypi setuptools3
