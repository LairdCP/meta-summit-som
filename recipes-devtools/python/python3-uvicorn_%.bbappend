FILESEXTRAPATHS:prepend:summitsom := "${THISDIR}/${PN}:"

SRC_URI += "file://1001-implement-asgiref-tls-extension.patch"
