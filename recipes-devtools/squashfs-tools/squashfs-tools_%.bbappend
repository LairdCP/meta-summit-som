
PACKAGECONFIG ??= "gzip zstd xattr reproducible"